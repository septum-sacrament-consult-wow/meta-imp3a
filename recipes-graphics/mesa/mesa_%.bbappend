DRIDRIVERS_append_powerpc64 = ",radeon"
